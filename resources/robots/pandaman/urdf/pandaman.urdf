Commit message: mujoco

File: resources/robots/pandaman/urdf/pandaman.urdf (robot description, URDF)
Before this commit: robot pandaman, 17 links, 16 joints
Links:
- added link world
Joints:
- added joint floating_base_joint: type floating, parent world, child base_link
